# Keil uVision project 综合时钟.uvproj, settings and files
target 综合时钟 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 综合时钟 +hex
  c flags: Optimize=8 SizeSpeed=1
  group user
    ../user/: main.c
    ../user/DS1302/: DS1302.c
    ../user/LCD1602/: LCD1602.c
    ../user/KEY/: key.c
    ../user/RS232/: RS232.c
    ../user/IR/: IR.c
